# Keil uVision project tx.uvprojx, settings and files
target tx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tx
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\..\src\hal\stm32f103xx\inc;..\..\..\src\mcu\STM32F1xx\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\src\mcu\STM32F1xx\CMSIS\Include;..\..\..\src\mcu\STM32F1xx\STM32F1xx_HAL_Driver\Inc;..\..\..\src\mcu\STM32F1xx\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\src\radio\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ../../../src/apps/stm32f103xb/tx/: main.c
  group hal
    ../../../src/hal/stm32f103xx/src/: hal_interface.c init.c startup_stm32f103xb.s stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
  group mcu
    ../../../src/mcu/STM32F1xx/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group radio
    ../../../src/radio/src/: sx1276.c sx1276-board.c timer.c
software components: CMSIS:CORE 5.0.1
