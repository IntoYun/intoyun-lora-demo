# Keil uVision project rx.uvprojx, settings and files
target rx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rx
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ..\..\..\src\hal\stm32f411xx\inc;..\..\..\src\mcu\STM32F4xx\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\src\mcu\STM32F4xx\CMSIS\Include;..\..\..\src\mcu\STM32F4xx\STM32F4xx_HAL_Driver\Inc;..\..\..\src\mcu\STM32F4xx\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\src\radio\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group apps
    ../../../src/apps/stm32f411xe/rx/: main.c
  group hal
    ../../../src/hal/stm32f411xx/src/: hal_interface.c init.c startup_stm32f411xe.s stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group mcu
    ../../../src/mcu/STM32F4xx/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group radio
    ../../../src/radio/src/: sx1276.c sx1276-board.c timer.c
software components: CMSIS:CORE 5.0.1
